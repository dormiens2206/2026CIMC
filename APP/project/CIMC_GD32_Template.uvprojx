# Keil uVision project CIMC_GD32_Template.uvprojx, settings and files
target CIMC_GD32_Template (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CIMC_GD32_Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,NDEBUG
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\HeaderFiles;..\Function;..\CMSIS\GD\GD32F4xx\Include;..\Driver;..\Driver\ADC;..\Driver\DAC;..\Driver\GD30AD3344_standard_peripheral\Include;..\Driver\KEY;..\Driver\LED;..\Driver\OLED;..\Driver\PMU;..\Driver\RCU;..\Driver\RTC;..\Driver\SPI_FLASH;..\Driver\SPI;..\Driver\TIMER;..\Protocol;..\Application;..\Middlewares\FreeModbus\include;..\Config;..\Middlewares\FreeModbus\rtu;..\Middlewares\FreeModbus\function;..\Middlewares\FreeModbus\port;..\Middlewares\FreeModbus\ascii;..\Middlewares\FatFS;..\Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Driver
    ../Driver/: USART_485.h USART_485.c sdcard.c
    ../Driver/TIMER/: timer.c timer.h
    ../Driver/SPI_FLASH/: SPI_FLASH.c SPI_FLASH.h
    ../Driver/SPI/: spi_def.h spi_port.c spi_port.h
    ../Driver/RTC/: RTC.c RTC.h
    ../Driver/RCU/: RCU.c RCU.h
    ../Driver/PMU/: PMU.c PMU.h
    ../Driver/OLED/: OLED.c OLED.h OLEDfont.h
    ../Driver/LED/: LED.c LED.h
    ../Driver/KEY/: KEY.c KEY.h
    ../Driver/GD30AD3344_standard_peripheral/Source/: gd30ad3344.c
    ../Driver/GD30AD3344_standard_peripheral/Include/: gd30ad3344.h
    ../Driver/DAC/: DAC.c DAC.h
    ../Driver/ADC/: ADC.c ADC.h
  group Function
    ../Function/: Function.c Function.h pt100.c pt100.h alarm_task.c alarm_task.h app_task.c app_task.h flash_param.c flash_param.h sample_task.c sample_task.h memory.h
  group Protocol
    ../Protocol/: uart_protocol.c uart_protocol.h protocol_frame.c protocol_tran.c
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Application
    ../Application/: app_display.c app_modbus_map.c app_param.c app_sample.c app_storage.c
  group FreeModbus_Core
    ../Middlewares/FreeModbus/: mb.c
  group FreeModbus_RTU
    ../Middlewares/FreeModbus/rtu/: mbcrc.c mbrtu.c
  group FreeModbus_Functions
    ../Middlewares/FreeModbus/function/: mbutils.c mbfuncholding.c mbfuncinput.c mbfunccoils.c mbfuncdisc.c
  group FreeModbus_Port
    ../Middlewares/FreeModbus/port/: port.c portevent.c portserial.c porttimer.c
  group Fats
    ../Middlewares/FatFS/: diskio.c ff.c
software components: CMSIS:CORE 5.1.1
